# Keil uVision project YH-uCOS-III.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: YH-uCOS-III
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\User;..\User\uCOS-III\Source;..\User\uCOS-III\Ports;..\User\uC-CPU;..\User\uC-LIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../User/: app.c
  group uC/OS-III Source
    ../User/uCOS-III/Source/: os.h os_cfg.h os_core.c os_task.c os_time.c os_type.h os_var.c os_cfg_app.h os_cfg_app.c os_prio.c os_tick.c
  group uC/OS-III Ports
    ../User/uCOS-III/Ports/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group uC/CPU
    ../User/uC-CPU/: cpu.h cpu_a.asm cpu_core.c cpu_core.h cpu_cfg.h cpu_def.h
  group Doc
    ../Doc/: readm.txt
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.1
