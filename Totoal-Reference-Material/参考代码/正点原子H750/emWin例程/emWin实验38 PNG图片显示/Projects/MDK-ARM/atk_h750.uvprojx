# Keil uVision project atk_h750.uvprojx, settings and files
target emWin (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: atk_h750 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32H750xx,USE_HAL_DRIVER
  c misc: --locale=english --diag_suppress=1294 --diag_suppress=111 --diag_suppress=1035
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\..\Drivers\STM32H7xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers;..\..\User;..\..\Middlewares\uC-OS3\uC-CPU\Cfg\Template;..\..\Middlewares\uC-OS3\uC-CPU\ARM-Cortex-M\ARMv7-M\ARM;..\..\Middlewares\uC-OS3\uC-CPU;..\..\Middlewares\uC-OS3\uC-LIB\Cfg\Template;..\..\Middlewares\uC-OS3\uC-LIB;..\..\Middlewares\uC-OS3\uC-OS3\Cfg\Template;..\..\Middlewares\uC-OS3\uC-OS3\Ports\ARM-Cortex-M\ARMv7-M\ARM;..\..\Middlewares\uC-OS3\uC-OS3\Source;..\..\Middlewares;..\..\Middlewares\emWin\Config;..\..\Middlewares\emWin\inc;..\..\Middlewares\emWin\emWin_Demo;..\..\Middlewares\emWin\STemWinHZ;..\..\Middlewares\emWin\TRUETYPE
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\..\User\SCRIPT\qspi_code.scf.scf
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
  group User
    ../../User/: main.c stm32h7xx_it.c uc-os3_demo.c
    ../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_sram.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_qspi.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/MPU/: mpu.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/TOUCH/: ctiic.c ft5206.c gt9xxx.c touch.c
    ../../Drivers/BSP/IIC/: myiic.c
    ../../Drivers/BSP/24CXX/: 24cxx.c
    ../../Drivers/BSP/NORFLASH/: norflash.c norflash_ex.c
    ../../Drivers/BSP/QSPI/: qspi.c
    ../../Drivers/BSP/SDMMC/: sdmmc_sdcard.c
    ../../Drivers/BSP/LCD/: lcd.c
  group Middlewares/MALLOC
    ../../Middlewares/MALLOC/: malloc.c
  group Middlewares/TEXT
    ../../Middlewares/TEXT/: fonts.c text.c
  group Middlewares/FATFS
    ../../Middlewares/FATFS/exfuns/: exfuns.c fattester.c
    ../../Middlewares/FATFS/source/: diskio.c ff.c ffsystem.c ffunicode.c
  group Middlewares/emWin/Config
    ../../Middlewares/emWin/Config/: GUI_X_Touch_Analog.c GUIConf.c GUIDRV_Template.c LCDConf.c
  group Middlewares/emWin/Lib
    ../../Middlewares/emWin/Lib/: GUI_CM4F_L.lib
  group Middlewares/emWin/OS
    ../../Middlewares/emWin/OS/: GUI_X_uCOS.c
  group Middlewares/emWin/STemWinHz
    ../../Middlewares/emWin/STemWinHZ/: GUI_FontHZ12.c GUI_FontHZ16.c GUI_FontHZ24.c GUI_FontHZ32.c GUI_UC_EncodeNone.c GUICharPEx.c
  group Middlewares/emWin/emWin_Demo
    ../../Middlewares/emWin/emWin_Demo/: emwin_demo.c
  group Middlewares/emWin/STemWinPNG
    ../../Middlewares/emWin/STemWinPNG/: adler32.c compress.c crc32.c deflate.c GUI_PNG.c gzio.c IMAGE_PNG.c infback.c inffast.c inflate.c inftrees.c png.c pngerror.c pnggccrd.c pngget.c pngmem.c pngpread.c pngread.c pngrio.c pngrtran.c pngrutil.c pngset.c pngtrans.c pngvcrd.c pngwio.c pngwrite.c pngwtran.c pngwutil.c trees.c uncompr.c zutil.c
  group Middlewares/emWin/TRUETYPE
    ../../Middlewares/emWin/TRUETYPE/: autofit.c bdf.c cff.c ftbase.c ftbbox.c ftbdf.c ftbitmap.c ftcache.c ftdebug.c ftglyph.c ftgxval.c ftgzip.c ftinit.c ftlzw.c ftmm.c ftotval.c ftpfr.c ftstroke.c ftsynth.c ftsystem.c fttype1.c ftwinfnt.c ftxf86.c GUI_TTF.c pcf.c pfr.c psaux.c pshinter.c psnames.c raster.c sfnt.c smooth.c truetype.c type1.c type1cid.c type42.c winfnt.c
  group Middlewares/uC-OS3/BSP
    ../../Middlewares/uC-OS3/uC-CPU/BSP/Template/: bsp_cpu.c
    ../../Middlewares/uC-OS3/uC-OS3/Template/: bsp_os_dt.c
  group Middlewares/uC-OS3/CPU
    ../../Middlewares/uC-OS3/uC-CPU/: cpu_core.c
    ../../Middlewares/uC-OS3/uC-CPU/ARM-Cortex-M/ARMv7-M/: cpu_c.c
    ../../Middlewares/uC-OS3/uC-CPU/ARM-Cortex-M/ARMv7-M/ARM/: cpu_a.asm
  group Middlewares/uC-OS3/LIB
    ../../Middlewares/uC-OS3/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group Middlewares/uC-OS3/OS3
    ../../Middlewares/uC-OS3/uC-OS3/Cfg/Template/: os_app_hooks.c
    ../../Middlewares/uC-OS3/uC-OS3/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
    ../../Middlewares/uC-OS3/uC-OS3/Ports/ARM-Cortex-M/ARMv7-M/ARM/: os_cpu_a.asm
    ../../Middlewares/uC-OS3/uC-OS3/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group Readme
    ../../: readme.txt
