# Keil uVision project atk_h750.uvprojx, settings and files
target TEST (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: atk_h750 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32H750xx,USE_USB_FS
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\..\Drivers\CMSIS\Include;..\..\Middlewares;..\..\Drivers;..\..\User;..\..\User\APP;..\..\Middlewares\GUI;..\..\Middlewares\NES;..\..\Middlewares\SMS;..\..\Middlewares\USB\STM32_USB_Device_Library\Core\Inc;..\..\Middlewares\USB\STM32_USB_Device_Library\Class\MSC\Inc;..\..\Middlewares\USB\STM32_USB_Host_Library\Core\Inc;..\..\Middlewares\USB\STM32_USB_Host_Library\Class\HID\Inc;..\..\Middlewares\USB\STM32_USB_Host_Library\Class\MSC\Inc;..\..\Middlewares\USB\USB_APP;..\..\Middlewares\USB\USB_HAL;..\..\Middlewares\ATKFREC;..\..\Middlewares\ATKQR;..\..\Middlewares\QR_ENCODE;..\..\Middlewares\UCOSII\uC-CPU\ARM-Cortex-M\ARMv7-M\ARM;..\..\Middlewares\UCOSII\uC-CPU\Cfg\Template;..\..\Middlewares\UCOSII\uC-CPU;..\..\Middlewares\UCOSII\uC-LIB\Cfg\Template;..\..\Middlewares\UCOSII\uC-LIB;..\..\Middlewares\UCOSII\uC-OS2\Cfg\Template;..\..\Middlewares\UCOSII\uC-OS2\Ports\ARM-Cortex-M\ARMv7-M\ARM;..\..\Middlewares\UCOSII\uC-OS2\Source
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\..\User\SCRIPT\qspi_code.scf.scf
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
  group User
    ../../User/: main.c
  group User/APP
    ../../User/APP/: spb.c common.c ebook.c picviewer.c settings.c videoplay.c calendar.c notepad.c exeplay.c paint.c calculator.c nesplay.c camera.c wirelessplay.c usbplay.c facereco.c qrplay.c rgbledplay.c appplay.c appplay_remote.c beepplay.c keyplay.c ledplay.c vmeterplay.c phoneplay.c smsplay.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/MPU/: mpu.c
    ../../Drivers/BSP/LCD/: lcd.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/SDMMC/: sdmmc_sdcard.c
    ../../Drivers/BSP/QSPI/: qspi.c
    ../../Drivers/BSP/NORFLASH/: norflash.c norflash_ex.c
    ../../Drivers/BSP/JPEGCODEC/: jpegcodec.c
    ../../Drivers/BSP/TIMER/: timer.c
    ../../Drivers/BSP/IIC/: myiic.c
    ../../Drivers/BSP/24CXX/: 24cxx.c
    ../../Drivers/BSP/TOUCH/: ctiic.c ft5206.c gt9xxx.c touch.c
    ../../Drivers/BSP/USART2/: usart2.c
    ../../Drivers/BSP/BEEP/: beep.c
    ../../Drivers/BSP/RTC/: rtc.c
    ../../Drivers/BSP/DS18B20/: ds18b20.c
    ../../Drivers/BSP/DMA/: dma.c
    ../../Drivers/BSP/ADC/: adc.c adc3.c
    ../../Drivers/BSP/LSENS/: lsens.c
    ../../Drivers/BSP/REMOTE/: remote.c
    ../../Drivers/BSP/SPBLCD/: spblcd.c
    ../../Drivers/BSP/GSM/: gsm.c
    ../../Drivers/BSP/NRF24L01/: nrf24l01.c
    ../../Drivers/BSP/SPI/: spi.c
    ../../Drivers/BSP/DCMI/: dcmi.c
    ../../Drivers/BSP/OV5640/: ov5640.c sccb.c
  group Middlewares/uC-OS2/BSP
    ../../Middlewares/UCOSII/uC-CPU/BSP/Template/: bsp_cpu.c
  group Middlewares/uC-OS2/CPU
    ../../Middlewares/UCOSII/uC-CPU/ARM-Cortex-M/ARMv7-M/ARM/: cpu_a.asm
    ../../Middlewares/UCOSII/uC-CPU/ARM-Cortex-M/ARMv7-M/: cpu_c.c
    ../../Middlewares/UCOSII/uC-CPU/: cpu_core.c
  group Middlewares/uC-OS2/LIB
    ../../Middlewares/UCOSII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group Middlewares/uC-OS2/OS2
    ../../Middlewares/UCOSII/uC-OS2/Cfg/Template/: app_hooks.c
    ../../Middlewares/UCOSII/uC-OS2/Ports/ARM-Cortex-M/ARMv7-M/ARM/: os_cpu_a.asm os_dbg.c
    ../../Middlewares/UCOSII/uC-OS2/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
    ../../Middlewares/UCOSII/uC-OS2/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group Middlewares/MALLOC
    ../../Middlewares/MALLOC/: malloc.c
  group Middlewares/FATFS
    ../../Middlewares/FATFS/source/: diskio.c ff.c ffsystem.c
    ../../Middlewares/FATFS/exfuns/: exfuns.c fattester.c myffunicode.c
  group Middlewares/TEXT
    ../../Middlewares/TEXT/: text.c fonts.c
  group Middlewares/PICTURE
    ../../Middlewares/PICTURE/: bmp.c gif.c hjpgd.c piclib.c tjpgd.c
  group Middlewares/MJPEG
    ../../Middlewares/MJPEG/: avi.c mjpeg.c
  group Middlewares/USMART
    ../../Middlewares/USMART/: usmart.c usmart_config.c usmart_port.c usmart_str.c
  group Middlewares/GUI
    ../../Middlewares/GUI/: button.c edit.c filelistbox.c gui.c listbox.c memo.c progressbar.c scrollbar.c window.c
  group Middlewares/T9INPUT
    ../../Middlewares/T9INPUT/: pyinput.c t9input.c
  group Middlewares/ATKNCR
    ../../Middlewares/ATKNCR/: atk_ncr.c ATKNCR_M_V2.0.lib
  group Middlewares/ATKFREC
    ../../Middlewares/ATKFREC/: atk_frec.c ATKFREC_DF.lib
  group Middlewares/ATKQR
    ../../Middlewares/ATKQR/: atk_qrdecode.c ATK_QR_V1.4.lib
  group Middlewares/USB_CORE
    ../../Middlewares/USB/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../../Middlewares/USB/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/USB_CLASS
    ../../Middlewares/USB/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
    ../../Middlewares/USB/STM32_USB_Host_Library/Class/HID/Src/: usbh_hid.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c usbh_hid_gamepad.c
    ../../Middlewares/USB/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group Middlewares/USB_HAL
    ../../Middlewares/USB/USB_HAL/: stm32h7xx_hal_hcd.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c
  group Middlewares/USB_APP
    ../../Middlewares/USB/USB_APP/: usb_app.c usbd_conf.c usbd_desc.c usbd_storage.c usbh_conf.c usbh_diskio.c
  group Middlewares/NES
    ../../Middlewares/NES/: nes_main.c nes_apu.c nes_crc32.c nes_mapper.c nes_ppu.c 6502.s
  group Middlewares/SMS
    ../../Middlewares/SMS/: sms_main.c sms_render.c sms_sn76496.c sms_vdp.c sms_z80a.c
  group Middlewares/QR_ENCODE
    ../../Middlewares/QR_ENCODE/: qr_encode.c
  group Readme
    ../../: readme.txt
