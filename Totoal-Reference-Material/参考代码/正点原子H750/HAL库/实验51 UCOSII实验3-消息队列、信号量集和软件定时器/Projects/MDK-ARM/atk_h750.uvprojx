# Keil uVision project atk_h750.uvprojx, settings and files
target uC-OS2 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: atk_h750 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32H750xx,USE_HAL_DRIVER
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\..\Drivers\STM32H7xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Middlewares;..\..\Drivers;..\..\User;..\..\Middlewares\uC-OS2\uC-CPU\Cfg\Template;..\..\Middlewares\uC-OS2\uC-CPU\ARM-Cortex-M\ARMv7-M\ARM;..\..\Middlewares\uC-OS2\uC-CPU;..\..\Middlewares\uC-OS2\uC-LIB\Cfg\Template;..\..\Middlewares\uC-OS2\uC-LIB;..\..\Middlewares\uC-OS2\uC-OS2\Cfg\Template;..\..\Middlewares\uC-OS2\uC-OS2\Ports\ARM-Cortex-M\ARMv7-M\ARM;..\..\Middlewares\uC-OS2\uC-OS2\Source
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\..\User\SCRIPT\qspi_code.scf.scf
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
  group User
    ../../User/: main.c stm32h7xx_it.c uc-os2_demo.c
    ../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_mdma.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_fmc.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/24CXX/: 24cxx.c
    ../../Drivers/BSP/BEEP/: beep.c
    ../../Drivers/BSP/IIC/: myiic.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/LCD/: lcd.c
    ../../Drivers/BSP/MPU/: mpu.c
    ../../Drivers/BSP/TOUCH/: ctiic.c ft5206.c gt9xxx.c touch.c
  group Middlewares/MALLOC
    ../../Middlewares/MALLOC/: malloc.c
  group Middlewares/uC-OS2/BSP
    ../../Middlewares/uC-OS2/uC-CPU/BSP/Template/: bsp_cpu.c
  group Middlewares/uC-OS2/CPU
    ../../Middlewares/uC-OS2/uC-CPU/ARM-Cortex-M/ARMv7-M/ARM/: cpu_a.asm
    ../../Middlewares/uC-OS2/uC-CPU/ARM-Cortex-M/ARMv7-M/: cpu_c.c
    ../../Middlewares/uC-OS2/uC-CPU/: cpu_core.c
  group Middlewares/uC-OS2/LIB
    ../../Middlewares/uC-OS2/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group Middlewares/uC-OS2/OS2
    ../../Middlewares/uC-OS2/uC-OS2/Cfg/Template/: app_hooks.c
    ../../Middlewares/uC-OS2/uC-OS2/Ports/ARM-Cortex-M/ARMv7-M/ARM/: os_cpu_a.asm os_dbg.c
    ../../Middlewares/uC-OS2/uC-OS2/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
    ../../Middlewares/uC-OS2/uC-OS2/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group Readme
    ../../: readme.txt
