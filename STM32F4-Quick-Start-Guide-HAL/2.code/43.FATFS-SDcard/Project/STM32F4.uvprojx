# Keil uVision project STM32F4.uvprojx, settings and files
target Template (6190000::V6.19::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=1
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\Libraries;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_HAL_Driver\Inc;..\Middlewares;..\Middlewares\FATFS\source;..\Middlewares\FATFS\exfuns;..\User;..\User\BSP;..\User\SYSTEM\delay;..\User\SYSTEM\sys;..\User\SYSTEM\usart;..\User\BSP\led;..\User\BSP\key;..\User\BSP\lcd;..\User\BSP\sram;..\User\BSP\sdio;..\User\BSP\flash;..\User\BSP\spi
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Start
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group Libs
    ../Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_rng.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_sd.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_spi.c
  group Middlewares
    ../Middlewares/: SerialInvoker.c SerialInvoker_config.c malloc.c
    ../Middlewares/FATFS/source/: diskio.c ff.c ffsystem.c ffunicode.c
    ../Middlewares/FATFS/exfuns/: exfuns.c fattester.c
  group User/System
    ../User/SYSTEM/delay/: delay.c
    ../User/SYSTEM/sys/: sys.c
    ../User/SYSTEM/usart/: usart.c
  group User
    ../User/: main.c stm32f4xx_it.c
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group User/BSP
    ../User/BSP/led/: led.c
    ../User/BSP/: bsp_init.c
    ../User/BSP/key/: key.c
    ../User/BSP/lcd/: lcd.c font.h
    ../User/BSP/sram/: sram.c
    ../User/BSP/sdio/: sdio.c
    ../User/BSP/spi/: spi.c
    ../User/BSP/flash/: flash.c
  group README
    ../: README.md
