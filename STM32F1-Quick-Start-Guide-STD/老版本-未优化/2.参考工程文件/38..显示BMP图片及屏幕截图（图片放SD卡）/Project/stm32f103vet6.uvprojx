# Keil uVision project stm32f103vet6.uvprojx, settings and files
target BMP (5060960::V5.06 update 7 (build 960)::.\AC5)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=2 OneElfS=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\User;..\User\bmp;..\User\FATFS;..\User\FATFS\option;..\User\font;..\User\Key;..\User\lcd;..\User\led;..\User\sdio;..\User\usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: system_stm32f10x.c core_cm3.c system_stm32f10x.h stm32f10x.h
  group FWLB
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c stm32f10x_it.h stm32f10x_conf.h
    ../User/bmp/: bmp.c
    ../User/FATFS/: diskio.c ff.c
    ../User/font/: fonts.c
    ../User/Key/: key.c
    ../User/lcd/: ili9341_lcd.c
    ../User/led/: led.c
    ../User/sdio/: sdio_sdcard.c sdio_test.c
    ../User/usart/: usart.c
    ../User/FATFS/option/: syscall.c ccsbcs.c
  group DOC
    ../Doc/: readme.txt
